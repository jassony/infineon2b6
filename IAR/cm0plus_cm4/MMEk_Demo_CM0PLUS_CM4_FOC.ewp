# IAR project MMEk_Demo_CM0PLUS_CM4_FOC.ewp, settings and files
configuration Multi Motor Evalkit V1.0 (ARM, debug)
  General.OGChipSelectEditMenu: CYT2B6_M0+ Infineon CYT2B6_M0+
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: tviibe512k; CYT2B63CAE; CY_USE_PSVP=0; CPU_BOARD_REVC; CY_MCU_rev_d; USE_M0
  ICCARM.CCIncludePath2: ..\..\T2G_Sample_Driver_Library\common\hdr; ..\..\T2G_Sample_Driver_Library\common\hdr\cmsis\include; ..\..\T2G_Sample_Driver_Library\common\src\drivers; ..\..\T2G_Sample_Driver_Library\common\src\mw; ..\..\T2G_Sample_Driver_Library\tviibe512k\hdr\rev_d; ..\..\T2G_Sample_Driver_Library\tviibe512k\hdr\rev_d\ip; ..\..\T2G_Sample_Driver_Library\tviibe512k\hdr\rev_d\mcureg; ..\..\T2G_Sample_Driver_Library\tviibe512k\src; ..\..\T2G_Sample_Driver_Library\tviibe512k\src\interrupts\rev_d; ..\..\T2G_Sample_Driver_Library\tviibe512k\src\drivers; ..\..\T2G_Sample_Driver_Library\tviibe512k\src\system\rev_d; ..\..\M0_BSW\SOURCE\ld_gpio\inc; ..\..\M0_BSW\SOURCE\ld_adc\inc; ..\..\M0_BSW\SOURCE\ld_canfd\inc; ..\..\M0_BSW\SOURCE\ld_tcpwm\inc; ..\..\M0_BSW\SOURCE\ld_irq\inc; ..\..\T2G_Sample_Driver_Library\common\src\drivers\sysint; ..\..\M0_BSW\SOURCE\ld_task\inc; ..\..\T2G_Sample_Driver_Library\common\src\drivers\canfd; ..\..\T2G_Sample_Driver_Library\common\src\drivers\adc; ..\..\T2G_Sample_Driver_Library\common\src\drivers\systick; ..\..\T2G_Sample_Driver_Library\common\src\drivers\tcpwm; ..\..\T2G_Sample_Driver_Library\common\src\drivers\sysint; ..\..\T2G_Sample_Driver_Library\common\src\drivers\gpio; ..\..\M0_BSW\SOURCE\ld_sysclk\inc; ..\..\Common; ..\..\SoftTimer; ..\..\M0_BSW\SOURCE\ld_ipc\inc; ..\..\M0_M4_MID\inc; ..\..\M0_BSW\SOURCE\ld_app\inc; ..\..\M0_BSW\SOURCE\Rte\inc; ..\..\M0_BSW\SOURCE\ld_flash\inc; ..\..\M0_BSW\SOURCE\Eeprom\Eeprom App; ..\..\M0_BSW\SOURCE\Eeprom\Eeprom Ctrl; ..\..\M0_BSW\SOURCE\Eeprom\Eeprom Driver; ..\..\M0_BSW\SOURCE\CanUds\CanCom; ..\..\M0_BSW\SOURCE\CanUds\CanDcm; ..\..\M0_BSW\SOURCE\CanUds\CanDriver; ..\..\M0_BSW\SOURCE\CanUds\CanDtc; ..\..\M0_BSW\SOURCE\CanUds\CanIf; ..\..\M0_BSW\SOURCE\CanUds\CanTp; ..\..\M0_BSW\SOURCE\CanUds\User; ..\..\M0_BSW\SOURCE\SoftwareVersion; ..\..\M0_BSW\SOURCE\CanUds; ..\..\M0_BSW\SOURCE\RingBuf; ..\..\xcp; ..\..\xcp\xcp_cfg; ..\..\T2G_Sample_Driver_Library\common\src\drivers\sysreset; ..\..\T2G_Sample_Driver_Library\common\src\drivers\mcwdt; ..\..\M0_BSW\SOURCE\ld_wdg\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MMEk_Demo_CM0PLUS.hex
  ILINK.IlinkOutputFile: MMEk_Demo_CM0PLUS.out
  ILINK.IlinkConfigDefines: _CORE_cm0plus_=0; _LINK_flash_=0
  ILINK.IlinkIcfFile: ..\..\LinkerScript\linker_directives_tviibe512k.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSW/common
    ../../Common/: common_mem_op.c common_mem_op.h module_header_file.h performance_test.c performance_test.h platform_common_typdef.h
  group BSW/soft_timer
    ../../SoftTimer/: soft_timer.c soft_timer.h
  group BSW/SOURCE/CanUds
    ../../M0_BSW/SOURCE/CanUds/: can_common.h
  group BSW/SOURCE/CanUds/CanDcm
    ../../M0_BSW/SOURCE/CanUds/CanDcm/: can_dcm.c can_dcm.h can_dcm_cbk_cfg.h can_dcm_cfg.c can_dcm_cfg.h
  group BSW/SOURCE/CanUds/CanDriver
    ../../M0_BSW/SOURCE/CanUds/CanDriver/: can_driver.c can_driver.h
  group BSW/SOURCE/CanUds/CanDtc
    ../../M0_BSW/SOURCE/CanUds/CanDtc/: can_dtc.c can_dtc.h can_dtc_cbk_cfg.h can_dtc_cfg.c can_dtc_cfg.h
  group BSW/SOURCE/CanUds/CanIf
    ../../M0_BSW/SOURCE/CanUds/CanIf/: canif.c canif.h canif_cfg.c canif_cfg.h
  group BSW/SOURCE/CanUds/CanTp
    ../../M0_BSW/SOURCE/CanUds/CanTp/: cantp.c cantp.h cantp_cfg.c cantp_cfg.h
  group BSW/SOURCE/CanUds/User
    ../../M0_BSW/SOURCE/CanUds/User/: bootloader.c bootloader.h can_busoff.c can_busoff.h can_user.c can_user.h dtc_user.c dtc_user.h uds_user.c uds_user.h
  group BSW/SOURCE/Eeprom/Eeprom_App
    ../../M0_BSW/SOURCE/Eeprom/Eeprom App/: eeprom_app.c eeprom_app.h eeprom_app_cbk.h eeprom_app_cfg.c eeprom_app_cfg.h
  group BSW/SOURCE/Eeprom/Eeprom_Ctrl
    ../../M0_BSW/SOURCE/Eeprom/Eeprom Ctrl/: eeprom_ctrl.c eeprom_ctrl.h eeprom_ctrl_cfg.c eeprom_ctrl_cfg.h
  group BSW/SOURCE/Eeprom/Eeprom_Driver
    ../../M0_BSW/SOURCE/Eeprom/Eeprom Driver/: eeprom_driver.c eeprom_driver.h
  group BSW/SOURCE/ld_adc/inc
    ../../M0_BSW/SOURCE/ld_adc/inc/: m0_adc_cfg.h
  group BSW/SOURCE/ld_adc/src
    ../../M0_BSW/SOURCE/ld_adc/src/: m0_adc_cfg.c
  group BSW/SOURCE/ld_app/inc
    ../../M0_BSW/SOURCE/ld_app/inc/: m0_var.h ptc_duty_control.h user_funtion.h
  group BSW/SOURCE/ld_app/src
    ../../M0_BSW/SOURCE/ld_app/src/: m0_var.c ptc_duty_control.c user_funtion.c
  group BSW/SOURCE/ld_canfd/inc
    ../../M0_BSW/SOURCE/ld_canfd/inc/: m0_canfd_cfg.h
  group BSW/SOURCE/ld_canfd/src
    ../../M0_BSW/SOURCE/ld_canfd/src/: m0_canfd_cfg.c
  group BSW/SOURCE/ld_flash/inc
    ../../M0_BSW/SOURCE/ld_flash/inc/: m0_flash.h m0_flash_async.h
  group BSW/SOURCE/ld_flash/src
    ../../M0_BSW/SOURCE/ld_flash/src/: m0_flash.c m0_flash_async.c
  group BSW/SOURCE/ld_wdg/inc
    ../../M0_BSW/SOURCE/ld_wdg/inc/: m0_wdg.h
  group BSW/SOURCE/ld_wdg/src
    ../../M0_BSW/SOURCE/ld_wdg/src/: m0_wdg.c
  group BSW/SOURCE/ld_gpio/inc
    ../../M0_BSW/SOURCE/ld_gpio/inc/: m0_gpio_cfg.h
  group BSW/SOURCE/ld_gpio/src
    ../../M0_BSW/SOURCE/ld_gpio/src/: m0_gpio_cfg.c
  group BSW/SOURCE/ld_ipc/inc
    ../../M0_BSW/SOURCE/ld_ipc/inc/: m0_ipc_cfg.h
  group BSW/SOURCE/ld_ipc/src
    ../../M0_BSW/SOURCE/ld_ipc/src/: m0_ipc_cfg.c
  group BSW/SOURCE/ld_irq/inc
    ../../M0_BSW/SOURCE/ld_irq/inc/: m0_irq_cfg.h
  group BSW/SOURCE/ld_irq/src
    ../../M0_BSW/SOURCE/ld_irq/src/: m0_irq_cfg.c
  group BSW/SOURCE/ld_m0_m4_middle/inc
    ../../M0_M4_MID/inc/: m0_m4_ipc.h mid_include.h
  group BSW/SOURCE/ld_m0_m4_middle/src
    ../../M0_M4_MID/src/: m0_m4_ipc.c
  group BSW/SOURCE/ld_sysclk/inc
    ../../M0_BSW/SOURCE/ld_sysclk/inc/: m0_sysclk_cfg.h
  group BSW/SOURCE/ld_sysclk/src
    ../../M0_BSW/SOURCE/ld_sysclk/src/: m0_sysclk_cfg.c
  group BSW/SOURCE/ld_task/inc
    ../../M0_BSW/SOURCE/ld_task/inc/: m0_task.h
  group BSW/SOURCE/ld_task/src
    ../../M0_BSW/SOURCE/ld_task/src/: m0_task.c
  group BSW/SOURCE/ld_tcpwm/inc
    ../../M0_BSW/SOURCE/ld_tcpwm/inc/: m0_tcpwm_cfg.h
  group BSW/SOURCE/ld_tcpwm/src
    ../../M0_BSW/SOURCE/ld_tcpwm/src/: m0_tcpwm_cfg.c
  group BSW/SOURCE/RingBuf
    ../../M0_BSW/SOURCE/RingBuf/: ringbuf.c ringbuf.h
  group BSW/SOURCE/Rte/inc
    ../../M0_BSW/SOURCE/Rte/inc/: m0_rte.h
  group BSW/SOURCE/Rte/src
    ../../M0_BSW/SOURCE/Rte/src/: m0_rte.c
  group BSW/SOURCE/Software_Version
    ../../M0_M4_MID/src/: software_version.c
    ../../M0_M4_MID/inc/: software_version.h
  group Example
    ../../Example/CM0PLUS/: main_cm0plus.c
  group linkfile
    ../../LinkerScript/: linker_directives_tviibe512k.icf
  group T2G_Sample_Driver_Library/common/hdr
    ../../T2G_Sample_Driver_Library/common/hdr/: cy_project.h
  group T2G_Sample_Driver_Library/common/hdr/cmsis/include
    ../../T2G_Sample_Driver_Library/common/hdr/cmsis/include/: cmsis_compiler.h core_cm0plus.h
  group T2G_Sample_Driver_Library/common/src/drivers/adc
    ../../T2G_Sample_Driver_Library/common/src/drivers/adc/: cy_adc.c cy_adc.h
  group T2G_Sample_Driver_Library/common/src/drivers/canfd
    ../../T2G_Sample_Driver_Library/common/src/drivers/canfd/: cy_canfd.c cy_canfd.h
  group T2G_Sample_Driver_Library/common/src/drivers/cpu
    ../../T2G_Sample_Driver_Library/tviibe512k/src/drivers/cpu/: cy_cpu.c cy_cpu.h
  group T2G_Sample_Driver_Library/common/src/drivers/crypto
    ../../T2G_Sample_Driver_Library/common/src/drivers/crypto/: cy_crypto.h cy_crypto_common.h cy_crypto_config.c cy_crypto_config.h cy_crypto_server.h
  group T2G_Sample_Driver_Library/common/src/drivers/dma
    ../../T2G_Sample_Driver_Library/common/src/drivers/dma/: cy_mdma.c cy_mdma.h cy_pdma.c cy_pdma.h
  group T2G_Sample_Driver_Library/common/src/drivers/evtgen
    ../../T2G_Sample_Driver_Library/common/src/drivers/evtgen/: cy_evtgen.c cy_evtgen.h
  group T2G_Sample_Driver_Library/common/src/drivers/flash
    ../../T2G_Sample_Driver_Library/common/src/drivers/flash/: cy_flash.c cy_flash.h
  group T2G_Sample_Driver_Library/common/src/drivers/gpio
    ../../T2G_Sample_Driver_Library/common/src/drivers/gpio/: cy_gpio.c cy_gpio.h
  group T2G_Sample_Driver_Library/common/src/drivers/ipc
    ../../T2G_Sample_Driver_Library/common/src/drivers/ipc/: cy_ipc_config.h cy_ipc_drv.c cy_ipc_drv.h cy_ipc_pipe.c cy_ipc_pipe.h cy_ipc_sema.c cy_ipc_sema.h
  group T2G_Sample_Driver_Library/common/src/drivers/lin
    ../../T2G_Sample_Driver_Library/common/src/drivers/lin/: cy_lin.c cy_lin.h
  group T2G_Sample_Driver_Library/common/src/drivers/lvd
    ../../T2G_Sample_Driver_Library/common/src/drivers/lvd/: cy_lvd.c cy_lvd.h
  group T2G_Sample_Driver_Library/common/src/drivers/mcwdt
    ../../T2G_Sample_Driver_Library/common/src/drivers/mcwdt/: cy_mcwdt.c cy_mcwdt.h
  group T2G_Sample_Driver_Library/common/src/drivers/mpu
    ../../T2G_Sample_Driver_Library/common/src/drivers/mpu/: cy_mpu.c cy_mpu.h
  group T2G_Sample_Driver_Library/common/src/drivers/prot
    ../../T2G_Sample_Driver_Library/common/src/drivers/prot/: cy_prot.c cy_prot.h
  group T2G_Sample_Driver_Library/common/src/drivers/scb
    ../../T2G_Sample_Driver_Library/common/src/drivers/scb/: cy_scb_common.c cy_scb_common.h cy_scb_ezi2c.c cy_scb_ezi2c.h cy_scb_i2c.c cy_scb_i2c.h cy_scb_spi.c cy_scb_spi.h cy_scb_uart.c cy_scb_uart.h
  group T2G_Sample_Driver_Library/common/src/drivers/smartio
    ../../T2G_Sample_Driver_Library/common/src/drivers/smartio/: cy_smartio.c cy_smartio.h
  group T2G_Sample_Driver_Library/common/src/drivers/srom
    ../../T2G_Sample_Driver_Library/common/src/drivers/srom/: cy_srom.c cy_srom.h
  group T2G_Sample_Driver_Library/common/src/drivers/sysclk
    ../../T2G_Sample_Driver_Library/tviibe512k/src/drivers/sysclk/: cy_sysclk.c cy_sysclk.h
  group T2G_Sample_Driver_Library/common/src/drivers/sysflt
    ../../T2G_Sample_Driver_Library/common/src/drivers/sysflt/: cy_sysflt.c cy_sysflt.h
    ../../../../src/drivers/sysflt/: cy_sysflt_config.h
  group T2G_Sample_Driver_Library/common/src/drivers/sysint
    ../../T2G_Sample_Driver_Library/common/src/drivers/sysint/: cy_sysint.c cy_sysint.h
  group T2G_Sample_Driver_Library/common/src/drivers/syslib
    ../../T2G_Sample_Driver_Library/common/src/drivers/syslib/: cy_syslib.c cy_syslib.h
  group T2G_Sample_Driver_Library/common/src/drivers/syslib/iar
    ../../T2G_Sample_Driver_Library/common/src/drivers/syslib/iar/: cy_syslib_iar.s
  group T2G_Sample_Driver_Library/common/src/drivers/syspm
    ../../T2G_Sample_Driver_Library/common/src/drivers/syspm/: cy_syspm.c cy_syspm.h
  group T2G_Sample_Driver_Library/common/src/drivers/sysreset
    ../../T2G_Sample_Driver_Library/common/src/drivers/sysreset/: cy_sysreset.c cy_sysreset.h
  group T2G_Sample_Driver_Library/common/src/drivers/sysrtc
    ../../T2G_Sample_Driver_Library/common/src/drivers/sysrtc/: cy_sysrtc.c cy_sysrtc.h
  group T2G_Sample_Driver_Library/common/src/drivers/systick
    ../../T2G_Sample_Driver_Library/common/src/drivers/systick/: cy_systick.c cy_systick.h
  group T2G_Sample_Driver_Library/common/src/drivers/syswdt
    ../../T2G_Sample_Driver_Library/common/src/drivers/syswdt/: cy_syswdt.c cy_syswdt.h
  group T2G_Sample_Driver_Library/common/src/drivers/tcpwm
    ../../T2G_Sample_Driver_Library/common/src/drivers/tcpwm/: cy_tcpwm.c cy_tcpwm.h cy_tcpwm_counter.c cy_tcpwm_counter.h cy_tcpwm_pwm.c cy_tcpwm_pwm.h cy_tcpwm_quaddec.c cy_tcpwm_quaddec.h cy_tcpwm_sr.c cy_tcpwm_sr.h
  group T2G_Sample_Driver_Library/common/src/drivers/trigmux
    ../../T2G_Sample_Driver_Library/common/src/drivers/trigmux/: cy_trigmux.c cy_trigmux.h
  group T2G_Sample_Driver_Library/common/src/mw/flash
    ../../T2G_Sample_Driver_Library/common/src/mw/flash/: cy_mw_flash.c cy_mw_flash.h
  group T2G_Sample_Driver_Library/common/src/startup
    ../../T2G_Sample_Driver_Library/common/src/startup/: startup.c startup_customize.h
  group T2G_Sample_Driver_Library/common/src/startup/iar
    ../../T2G_Sample_Driver_Library/common/src/startup/iar/: startup_cm0plus.s
  group T2G_Sample_Driver_Library/tviibe512k/hdr/rev_d
    ../../T2G_Sample_Driver_Library/tviibe512k/hdr/rev_d/: bb_bsp_tviibe512k.h cy_device_headers.h cyt2b63cae.h cyt2b6_config.h
  group T2G_Sample_Driver_Library/tviibe512k/hdr/rev_d/ip
    ../../T2G_Sample_Driver_Library/tviibe512k/hdr/rev_d/ip/: cyip_backup_v2.h cyip_canfd.h cyip_coredefines.h cyip_cpuss_v2.h cyip_crypto_v2.h cyip_dmac_v2.h cyip_dw_v2.h cyip_efuse_data_v2.h cyip_efuse_v2.h cyip_evtgen.h cyip_fault_v2.h cyip_flashc_v2.h cyip_gpio_v2.h cyip_headers.h cyip_hsiom_v2.h cyip_ipc_v2.h cyip_lin.h cyip_pass.h cyip_peri_ms_v2.h cyip_peri_v2.h cyip_prot_v2.h cyip_scb_v2.h cyip_sflash_v2.h cyip_smartio_v2.h cyip_srss_v2.h cyip_tcpwm_v2.h
    ../../T2G_Sample_Driver_Library/tviibe512k/hdr/rev_d/: gpio_cyt2b6_64_lqfp.h
  group T2G_Sample_Driver_Library/tviibe512k/src/interrupts/rev_d
    ../../T2G_Sample_Driver_Library/tviibe512k/src/interrupts/rev_d/: cy_interrupt_map.c cy_interrupt_map_cm0plus.h cy_interrupt_map_cm4.h
  group T2G_Sample_Driver_Library/tviibe512k/src/system/rev_d
    ../../T2G_Sample_Driver_Library/tviibe512k/src/system/rev_d/: system_cyt2b7.h system_tviibe512k_cm0plus.c
  group Xcp
    ../../xcp/: XcpProf.c XcpProf.h xcp_appl.c xcp_cal_test.c xcp_cal_test.h xcp_can.c xcp_can.h xcp_port.c xcp_port.h
  group Xcp/xcp_cfg
    ../../xcp/xcp_cfg/: xcp_cfg.h xcp_par.c xcp_par.h
